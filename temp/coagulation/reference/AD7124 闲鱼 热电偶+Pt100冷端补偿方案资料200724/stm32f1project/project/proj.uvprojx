# Keil uVision project proj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\header;..\STM32F10x_StdPeriph_Driver\inc;..\user;..\STM32F10x_StdPeriph_Driver\src;..\core\CMSIS\CM3\CoreSupport;..\AD7124
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group libraries
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group header
    ../header/: Delay.h DeviceInit.h Global.h header.h stm32f10x_conf.h stm32f10x_it.h usart.h
  group user
    ../user/: Delay.c DeviceInit.c Global.c main.c stm32f10x_it.c usart.c pt100.c Thermocouple.c
  group ad7124
    ../AD7124/: ad7124.c
