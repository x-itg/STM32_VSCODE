# Keil uVision project AD7124.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\AD7705;..\HARDWARE\MOTOR;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\LCD12864;..\HARDWARE\TLC5615;..\HARDWARE\TIMER;..\HARDWARE\W5500;..\HARDWARE\EC20;..\HARDWARE\ESP-12F;..\SYSTEM\list;..\HARDWARE\AD7124_8;..\SYSTEM\fifo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/AD7124_8/: ad7124.c communication.c myspi.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../SYSTEM/delay/: delay.c
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c
  group READER
    ./: reader.txt
software components: CMSIS:CORE 5.1.2
